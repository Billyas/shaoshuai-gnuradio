options:
  parameters:
    generate_options: qt_gui
    id: shoashuai
    output_language: python
    title: 少帅下飞机✈️
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '88200'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Billy\Desktop\aa\b.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '2940'
    type: complex
    xmax: '20'
    xmin: '-20'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
